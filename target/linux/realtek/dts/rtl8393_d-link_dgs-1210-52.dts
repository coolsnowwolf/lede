// SPDX-License-Identifier: GPL-2.0-or-later OR MIT

#include "rtl839x.dtsi"
#include "rtl83xx_d-link_dgs-1210_common.dtsi"
#include "rtl83xx_d-link_dgs-1210_gpio.dtsi"
#include "rtl83xx_d-link_dgs-1210_gpio_sfp.dtsi"

/ {
	compatible = "d-link,dgs-1210-52", "realtek,rtl8393-soc";
	model = "D-Link DGS-1210-52";
};

&mdio_bus0 {
	/* External phy RTL8218B #1 */
	PHY_C22(0, 0)
	PHY_C22(1, 1)
	PHY_C22(2, 2)
	PHY_C22(3, 3)
	PHY_C22(4, 4)
	PHY_C22(5, 5)
	PHY_C22(6, 6)
	PHY_C22(7, 7)

	/* External phy RTL8218B #2 */
	PHY_C22(8, 8)
	PHY_C22(9, 9)
	PHY_C22(10, 10)
	PHY_C22(11, 11)
	PHY_C22(12, 12)
	PHY_C22(13, 13)
	PHY_C22(14, 14)
	PHY_C22(15, 15)

	/* External phy RTL8218B #3 */
	PHY_C22(16, 16)
	PHY_C22(17, 17)
	PHY_C22(18, 18)
	PHY_C22(19, 19)
	PHY_C22(20, 20)
	PHY_C22(21, 21)
	PHY_C22(22, 22)
	PHY_C22(23, 23)
};

&mdio_bus1 {
	/* External phy RTL8218B #4 */
	PHY_C22(24, 0)
	PHY_C22(25, 1)
	PHY_C22(26, 2)
	PHY_C22(27, 3)
	PHY_C22(28, 4)
	PHY_C22(29, 5)
	PHY_C22(30, 6)
	PHY_C22(31, 7)

	/* External phy RTL8218B #5 */
	PHY_C22(32, 8)
	PHY_C22(33, 9)
	PHY_C22(34, 10)
	PHY_C22(35, 11)
	PHY_C22(36, 12)
	PHY_C22(37, 13)
	PHY_C22(38, 14)
	PHY_C22(39, 15)

	/* External phy RTL8218B #6 */
	PHY_C22(40, 16)
	PHY_C22(41, 17)
	PHY_C22(42, 18)
	PHY_C22(43, 19)
	PHY_C22(44, 20)
	PHY_C22(45, 21)
	PHY_C22(46, 22)
	PHY_C22(47, 23)

	/* External phy RTL8214FC */
	PHY_C22_SFP(48, 24, 0)
	PHY_C22_SFP(49, 25, 1)
	PHY_C22_SFP(50, 26, 2)
	PHY_C22_SFP(51, 27, 3)
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		SWITCH_PORT_SDS(0, 1, 0, 0, qsgmii)
		SWITCH_PORT_SDS(1, 2, 0, 1, qsgmii)
		SWITCH_PORT_SDS(2, 3, 0, 2, qsgmii)
		SWITCH_PORT_SDS(3, 4, 0, 3, qsgmii)
		SWITCH_PORT_SDS(4, 5, 1, 0, qsgmii)
		SWITCH_PORT_SDS(5, 6, 1, 1, qsgmii)
		SWITCH_PORT_SDS(6, 7, 1, 2, qsgmii)
		SWITCH_PORT_SDS(7, 8, 1, 3, qsgmii)

		SWITCH_PORT_SDS(8, 9, 2, 0, qsgmii)
		SWITCH_PORT_SDS(9, 10, 2, 1, qsgmii)
		SWITCH_PORT_SDS(10, 11, 2, 2, qsgmii)
		SWITCH_PORT_SDS(11, 12, 2, 3, qsgmii)
		SWITCH_PORT_SDS(12, 13, 3, 0, qsgmii)
		SWITCH_PORT_SDS(13, 14, 3, 1, qsgmii)
		SWITCH_PORT_SDS(14, 15, 3, 2, qsgmii)
		SWITCH_PORT_SDS(15, 16, 3, 3, qsgmii)

		SWITCH_PORT_SDS(16, 17, 4, 0, qsgmii)
		SWITCH_PORT_SDS(17, 18, 4, 1, qsgmii)
		SWITCH_PORT_SDS(18, 19, 4, 2, qsgmii)
		SWITCH_PORT_SDS(19, 20, 4, 3, qsgmii)
		SWITCH_PORT_SDS(20, 21, 5, 0, qsgmii)
		SWITCH_PORT_SDS(21, 22, 5, 1, qsgmii)
		SWITCH_PORT_SDS(22, 23, 5, 2, qsgmii)
		SWITCH_PORT_SDS(23, 24, 5, 3, qsgmii)

		SWITCH_PORT_SDS(24, 25, 6, 0, qsgmii)
		SWITCH_PORT_SDS(25, 26, 6, 1, qsgmii)
		SWITCH_PORT_SDS(26, 27, 6, 2, qsgmii)
		SWITCH_PORT_SDS(27, 28, 6, 3, qsgmii)
		SWITCH_PORT_SDS(28, 29, 7, 0, qsgmii)
		SWITCH_PORT_SDS(29, 30, 7, 1, qsgmii)
		SWITCH_PORT_SDS(30, 31, 7, 2, qsgmii)
		SWITCH_PORT_SDS(31, 32, 7, 3, qsgmii)

		SWITCH_PORT_SDS(32, 33, 8, 0, qsgmii)
		SWITCH_PORT_SDS(33, 34, 8, 1, qsgmii)
		SWITCH_PORT_SDS(34, 35, 8, 2, qsgmii)
		SWITCH_PORT_SDS(35, 36, 8, 3, qsgmii)
		SWITCH_PORT_SDS(36, 37, 9, 0, qsgmii)
		SWITCH_PORT_SDS(37, 38, 9, 1, qsgmii)
		SWITCH_PORT_SDS(38, 39, 9, 2, qsgmii)
		SWITCH_PORT_SDS(39, 40, 9, 3, qsgmii)

		SWITCH_PORT_SDS(40, 41, 10, 0, qsgmii)
		SWITCH_PORT_SDS(41, 42, 10, 1, qsgmii)
		SWITCH_PORT_SDS(42, 43, 10, 2, qsgmii)
		SWITCH_PORT_SDS(43, 44, 10, 3, qsgmii)
		SWITCH_PORT_SDS(44, 45, 11, 0, qsgmii)
		SWITCH_PORT_SDS(45, 46, 11, 1, qsgmii)
		SWITCH_PORT_SDS(46, 47, 11, 2, qsgmii)
		SWITCH_PORT_SDS(47, 48, 11, 3, qsgmii)

		SWITCH_PORT_SDS(48, 49, 12, 0, qsgmii)
		SWITCH_PORT_SDS(49, 50, 12, 1, qsgmii)
		SWITCH_PORT_SDS(50, 51, 12, 2, qsgmii)
		SWITCH_PORT_SDS(51, 52, 12, 3, qsgmii)

		/* CPU-Port */
		port@52 {
			ethernet = <&ethernet0>;
			reg = <52>;
			phy-mode = "internal";
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};
