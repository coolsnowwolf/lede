// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl839x.dtsi"

#include <dt-bindings/leds/common.h>
#include <dt-bindings/input/input.h>
#include <dt-bindings/gpio/gpio.h>

/ {
	compatible = "edgecore,ecs2100-52t", "realtek,rtl839x-soc";
	model = "Edgecore ECS2100-52T";

	chosen {
		stdout-path = "serial0:115200n8";
	};

	aliases {
		label-mac-device = &ethernet0;
		led-boot = &led_diag;
		led-failsafe = &led_diag;
		led-running = &led_diag;
		led-upgrade = &led_diag;
	};

	memory@0 {
		device_type = "memory";
		reg = <0x0 0x10000000>;
	};

	leds {
		pinctrl-names = "default";
		pinctrl-0 = <&pinmux_disable_sys_led>;
		compatible = "gpio-leds";

		led_diag: diag {
			color = <LED_COLOR_ID_GREEN>;
			function = "diag";
			gpios = <&gpio0 0 GPIO_ACTIVE_LOW>;
		};
	};

	gpio-restart {
		compatible = "gpio-restart";
		gpios = <&gpio1 26 GPIO_ACTIVE_LOW>;
	};

	keys: keys {
		compatible = "gpio-keys-polled";
		poll-interval = <20>;

		reset {
			label = "reset";
			gpios = <&gpio1 33 GPIO_ACTIVE_LOW>;
			linux,code = <KEY_RESTART>;
		};
	};

	i2c0: i2c-gpio-0 {
		compatible = "i2c-gpio";
		sda-gpios = <&gpio1 6 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio1 7 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <5>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp0: sfp-p49 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c0>;
		los-gpios = <&gpio0 12 GPIO_ACTIVE_HIGH>;
		mod-def0-gpios = <&gpio1 8 GPIO_ACTIVE_LOW>;
	};

	i2c1: i2c-gpio-1 {
		compatible = "i2c-gpio";
		sda-gpios = <&gpio1 1 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio1 2 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <5>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp1: sfp-p50 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c1>;
		los-gpios = <&gpio0 14 GPIO_ACTIVE_HIGH>;
		mod-def0-gpios = <&gpio1 3 GPIO_ACTIVE_LOW>;
	};

	i2c2: i2c-gpio-2 {
		compatible = "i2c-gpio";
		sda-gpios = <&gpio1 22 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio1 23 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <5>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp2: sfp-p51 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c2>;
		los-gpios = <&gpio0 21 GPIO_ACTIVE_HIGH>;
		mod-def0-gpios = <&gpio1 24 GPIO_ACTIVE_LOW>;
	};

	i2c3: i2c-gpio-3 {
		compatible = "i2c-gpio";
		sda-gpios = <&gpio1 11 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio1 12 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <5>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp3: sfp-p52 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c3>;
		los-gpios = <&gpio0 22 GPIO_ACTIVE_HIGH>;
		mod-def0-gpios = <&gpio1 13 GPIO_ACTIVE_LOW>;
	};

	i2c4: i2c-gpio-4 {
		compatible = "i2c-gpio";
		sda-gpios = <&gpio1 29 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio1 30 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <5>;
		#address-cells = <1>;
		#size-cells = <0>;

		adt7470: fan-controller@2f {
			compatible = "adi,adt7470";
			reg = <0x2f>;
			#pwm-cells = <3>;
		};

		lm75b: lm75b@48 {
			compatible = "national,lm75b";
			reg = <0x48>;

			#thermal-sensor-cells = <0>;
		};

		eeprom@56 {
			compatible = "atmel,24c32";
			reg = <0x56>;
		};
	};

	fan0: pwm-fan {
		compatible = "pwm-fan";

		pwms = <&adt7470 0 714286 0>;

		#cooling-cells = <2>;

		/*
		 * PWM signal generated by ADT7470 with a period of 714286ns (~1.4kHz).
		 * HARDWARE NOTE: The fan uses a 3-pin adapter (DC voltage control).
		 * Lacking native 4-pin PWM control, the power delivery circuit saturates
		 * at low duty cycle values. The real effective control range is between ~4% and ~12%.
		 *
		 * cooling-levels scale calculation (0-255):
		 * Formula: ( duty_cycle_ns / 714286ns ) * 255
		 *
		 *   0 = 0%   (0ns)        -> Stopped      (0% Max RPM)
		 *  17 = 6.6% (47619ns)    -> ~6436 RPM   (~49% Max RPM - Minimum stable threshold, no pulsing)
		 *  21 = 8.2% (58823ns)    -> ~8450 RPM   (~64% Max RPM - Medium load, steady airflow)
		 *  25 = 9.8% (70028ns)    -> ~10131 RPM  (~77% Max RPM - High load)
		 *  30 = 11.7% (84033ns)   -> ~11368 RPM  (~86% Max RPM - Maximum useful speed before saturation)
		 */
		cooling-levels = <0 17 21 25 30>;
	};

	watchdog {
		compatible = "linux,wdt-gpio";
		gpios = <&gpio0 20 GPIO_ACTIVE_LOW>;
		hw_algo = "toggle";
		hw_margin_ms = <1200>;
	};
};

&thermal_zones {
	cpu-thermal {
		trips {
			/delete-node/ cpu-crit;

			cpu_idle: trip0 {
				temperature = <0>;
				hysteresis = <0>;
				type = "active";
			};

			cpu_low: trip1 {
				temperature = <45000>;
				hysteresis = <3000>;
				type = "active";
			};

			cpu_medium: trip2 {
				temperature = <52000>;
				hysteresis = <2000>;
				type = "active";
			};

			cpu_high: trip3 {
				temperature = <60000>;
				hysteresis = <2000>;
				type = "active";
			};

			cpu_very_high: trip4 {
				temperature = <68000>;
				hysteresis = <2000>;
				type = "active";
			};

			/* readd cpu-crit in the end */
			cpu_crit: trip5 {
				temperature = <105000>;
				hysteresis = <2000>;
				type = "critical";
			};
		};

		cooling-maps {
			map0 {
				trip = <&cpu_idle>;
				cooling-device = <&fan0 0 0>;
			};

			map1 {
				trip = <&cpu_low>;
				cooling-device = <&fan0 0 1>;
			};

			map2 {
				trip = <&cpu_medium>;
				cooling-device = <&fan0 0 2>;
			};

			map3 {
				trip = <&cpu_high>;
				cooling-device = <&fan0 0 3>;
			};

			map4 {
				trip = <&cpu_very_high>;
				cooling-device = <&fan0 0 4>;
			};
		};
	};

	switch-thermal {
		polling-delay-passive = <2000>;
		polling-delay = <5000>;
		thermal-sensors = <&lm75b>;

		trips {
			switch_idle: trip0 {
				temperature = <0>;
				hysteresis = <0>;
				type = "active";
			};

			switch_low: trip1 {
				temperature = <45000>;
				hysteresis = <3000>;
				type = "active";
			};

			switch_medium: trip2 {
				temperature = <52000>;
				hysteresis = <2000>;
				type = "active";
			};

			switch_high: trip3 {
				temperature = <60000>;
				hysteresis = <2000>;
				type = "active";
			};

			switch_very_high: trip4 {
				temperature = <68000>;
				hysteresis = <2000>;
				type = "active";
			};

			switch_crit: trip5 {
				temperature = <105000>;
				hysteresis = <2000>;
				type = "critical";
			};
		};

		cooling-maps {
			map0 {
				trip = <&switch_idle>;
				cooling-device = <&fan0 0 0>;
			};

			map1 {
				trip = <&switch_low>;
				cooling-device = <&fan0 0 1>;
			};

			map2 {
				trip = <&switch_medium>;
				cooling-device = <&fan0 0 2>;
			};

			map3 {
				trip = <&switch_high>;
				cooling-device = <&fan0 0 3>;
			};

			map4 {
				trip = <&switch_very_high>;
				cooling-device = <&fan0 0 4>;
			};
		};
	};
};

&ethernet0 {
	/* Factory MAC address allocation:
	 * label/eth0 : hwinfo 0x00 (base MAC)
	 * lan<n>     : base MAC + n (e.g., lan1 = base MAC + 1)
	 */
	nvmem-cells = <&macaddr_factory 0>;
	nvmem-cell-names = "mac-address";
};

&mdio_aux {
	status = "okay";

	gpio1: expander@3 {
		compatible = "realtek,rtl8231";
		reg = <3>;

		gpio-controller;
		#gpio-cells = <2>;
		gpio-ranges = <&gpio1 0 0 37>;

		led-controller {
			compatible = "realtek,rtl8231-leds";
			status = "disabled";
		};
	};
};

&mdio_bus0 {
	reset-gpios = <&gpio0 23 GPIO_ACTIVE_LOW>;
	reset-delay-us = <2000>;
	reset-post-delay-us = <140000>;

	/* External phy RTL8218B #1 */
	ethernet-phy-package@0 {
		reg = <0>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C22(0, 0)
		PHY_C22(1, 1)
		PHY_C22(2, 2)
		PHY_C22(3, 3)
		PHY_C22(4, 4)
		PHY_C22(5, 5)
		PHY_C22(6, 6)
		PHY_C22(7, 7)
	};

	/* External phy RTL8218B #2 */
	ethernet-phy-package@8 {
		reg = <8>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C22(8, 8)
		PHY_C22(9, 9)
		PHY_C22(10, 10)
		PHY_C22(11, 11)
		PHY_C22(12, 12)
		PHY_C22(13, 13)
		PHY_C22(14, 14)
		PHY_C22(15, 15)
	};

	/* External phy RTL8218B #3 */
	ethernet-phy-package@16 {
		reg = <16>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C22(16, 16)
		PHY_C22(17, 17)
		PHY_C22(18, 18)
		PHY_C22(19, 19)
		PHY_C22(20, 20)
		PHY_C22(21, 21)
		PHY_C22(22, 22)
		PHY_C22(23, 23)
	};
};

&mdio_bus1 {
	/* External phy RTL8218B #4 */
	ethernet-phy-package@0 {
		reg = <0>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C22(24, 0)
		PHY_C22(25, 1)
		PHY_C22(26, 2)
		PHY_C22(27, 3)
		PHY_C22(28, 4)
		PHY_C22(29, 5)
		PHY_C22(30, 6)
		PHY_C22(31, 7)
	};

	/* External phy RTL8218B #5 */
	ethernet-phy-package@8 {
		reg = <8>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C22(32, 8)
		PHY_C22(33, 9)
		PHY_C22(34, 10)
		PHY_C22(35, 11)
		PHY_C22(36, 12)
		PHY_C22(37, 13)
		PHY_C22(38, 14)
		PHY_C22(39, 15)
	};

	/* External phy RTL8218B #6 */
	ethernet-phy-package@16 {
		reg = <16>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C22(40, 16)
		PHY_C22(41, 17)
		PHY_C22(42, 18)
		PHY_C22(43, 19)
		PHY_C22(44, 20)
		PHY_C22(45, 21)
		PHY_C22(46, 22)
		PHY_C22(47, 23)
	};

	/* External phy RTL8214FC */
	ethernet-phy-package@24 {
		reg = <24>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C22_SFP(48, 24, 0)
		PHY_C22_SFP(49, 25, 1)
		PHY_C22_SFP(50, 26, 2)
		PHY_C22_SFP(51, 27, 3)
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <10000000>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "u-boot";
				reg = <0x0 0x100000>; /* 1024k */
				read-only;
			};

			partition@100000 {
				label = "u-boot-env";
				reg = <0x100000 0x80000>; /* 512k */
			};

			partition@180000 {
				label = "hwinfo";
				reg = <0x180000 0x80000>; /* 512k */
				read-only;

				nvmem-layout {
					compatible = "fixed-layout";
					#address-cells = <1>;
					#size-cells = <1>;

					macaddr_factory: macaddr@0 {
						compatible = "mac-base";
						reg = <0x0 0x6>;
						#nvmem-cell-cells = <1>;
					};
				};

			};

			partition@200000 {
				label = "firmware"; /* vendor userdata */
				reg = <0x200000 0x1e00000>; /* 30720k */
			};
		};
	};
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		SWITCH_PORT_SDS(0, 1, 0, 0, qsgmii)
		SWITCH_PORT_SDS(1, 2, 0, 1, qsgmii)
		SWITCH_PORT_SDS(2, 3, 0, 2, qsgmii)
		SWITCH_PORT_SDS(3, 4, 0, 3, qsgmii)
		SWITCH_PORT_SDS(4, 5, 1, 0, qsgmii)
		SWITCH_PORT_SDS(5, 6, 1, 1, qsgmii)
		SWITCH_PORT_SDS(6, 7, 1, 2, qsgmii)
		SWITCH_PORT_SDS(7, 8, 1, 3, qsgmii)

		SWITCH_PORT_SDS(8, 9, 2, 0, qsgmii)
		SWITCH_PORT_SDS(9, 10, 2, 1, qsgmii)
		SWITCH_PORT_SDS(10, 11, 2, 2, qsgmii)
		SWITCH_PORT_SDS(11, 12, 2, 3, qsgmii)
		SWITCH_PORT_SDS(12, 13, 3, 0, qsgmii)
		SWITCH_PORT_SDS(13, 14, 3, 1, qsgmii)
		SWITCH_PORT_SDS(14, 15, 3, 2, qsgmii)
		SWITCH_PORT_SDS(15, 16, 3, 3, qsgmii)

		SWITCH_PORT_SDS(16, 17, 4, 0, qsgmii)
		SWITCH_PORT_SDS(17, 18, 4, 1, qsgmii)
		SWITCH_PORT_SDS(18, 19, 4, 2, qsgmii)
		SWITCH_PORT_SDS(19, 20, 4, 3, qsgmii)
		SWITCH_PORT_SDS(20, 21, 5, 0, qsgmii)
		SWITCH_PORT_SDS(21, 22, 5, 1, qsgmii)
		SWITCH_PORT_SDS(22, 23, 5, 2, qsgmii)
		SWITCH_PORT_SDS(23, 24, 5, 3, qsgmii)

		SWITCH_PORT_SDS(24, 25, 6, 0, qsgmii)
		SWITCH_PORT_SDS(25, 26, 6, 1, qsgmii)
		SWITCH_PORT_SDS(26, 27, 6, 2, qsgmii)
		SWITCH_PORT_SDS(27, 28, 6, 3, qsgmii)
		SWITCH_PORT_SDS(28, 29, 7, 0, qsgmii)
		SWITCH_PORT_SDS(29, 30, 7, 1, qsgmii)
		SWITCH_PORT_SDS(30, 31, 7, 2, qsgmii)
		SWITCH_PORT_SDS(31, 32, 7, 3, qsgmii)

		SWITCH_PORT_SDS(32, 33, 8, 0, qsgmii)
		SWITCH_PORT_SDS(33, 34, 8, 1, qsgmii)
		SWITCH_PORT_SDS(34, 35, 8, 2, qsgmii)
		SWITCH_PORT_SDS(35, 36, 8, 3, qsgmii)
		SWITCH_PORT_SDS(36, 37, 9, 0, qsgmii)
		SWITCH_PORT_SDS(37, 38, 9, 1, qsgmii)
		SWITCH_PORT_SDS(38, 39, 9, 2, qsgmii)
		SWITCH_PORT_SDS(39, 40, 9, 3, qsgmii)

		SWITCH_PORT_SDS(40, 41, 10, 0, qsgmii)
		SWITCH_PORT_SDS(41, 42, 10, 1, qsgmii)
		SWITCH_PORT_SDS(42, 43, 10, 2, qsgmii)
		SWITCH_PORT_SDS(43, 44, 10, 3, qsgmii)
		SWITCH_PORT_SDS(44, 45, 11, 0, qsgmii)
		SWITCH_PORT_SDS(45, 46, 11, 1, qsgmii)
		SWITCH_PORT_SDS(46, 47, 11, 2, qsgmii)
		SWITCH_PORT_SDS(47, 48, 11, 3, qsgmii)

		SWITCH_PORT_SDS(48, 49, 12, 0, qsgmii)
		SWITCH_PORT_SDS(49, 50, 12, 1, qsgmii)
		SWITCH_PORT_SDS(50, 51, 12, 2, qsgmii)
		SWITCH_PORT_SDS(51, 52, 12, 3, qsgmii)

		/* CPU-Port */
		port@52 {
			ethernet = <&ethernet0>;
			reg = <52>;
			phy-mode = "internal";
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};
