// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl9302_zyxel_xgs1210-12-common.dtsi"

/ {
	compatible = "zyxel,xgs1210-12-b1", "realtek,rtl9302-soc";
	model = "Zyxel XGS1210-12 B1 Switch";
};

&mdio_bus1 {
	PHY_C45(24, 1)
};

&mdio_bus2 {
	PHY_C45(25, 2)
};
