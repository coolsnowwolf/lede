// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl8380_zyxel_gs1900.dtsi"
#include "rtl8380_zyxel_gs1900_gpio.dtsi"

/ {
	compatible = "zyxel,gs1900-16", "realtek,rtl838x-soc";
	model = "Zyxel GS1900-16";
};

&mdio {
	EXTERNAL_PHY(16)
	EXTERNAL_PHY(17)
	EXTERNAL_PHY(18)
	EXTERNAL_PHY(19)
	EXTERNAL_PHY(20)
	EXTERNAL_PHY(21)
	EXTERNAL_PHY(22)
	EXTERNAL_PHY(23)
};

&switch0 {
	ports {
		SWITCH_PORT(16, 9, qsgmii)
		SWITCH_PORT(17, 10, qsgmii)
		SWITCH_PORT(18, 11, qsgmii)
		SWITCH_PORT(19, 12, qsgmii)
		SWITCH_PORT(20, 13, qsgmii)
		SWITCH_PORT(21, 14, qsgmii)
		SWITCH_PORT(22, 15, qsgmii)
		SWITCH_PORT(23, 16, qsgmii)
	};
};

&gpio1 {
	/delete-node/ poe_enable;
};
