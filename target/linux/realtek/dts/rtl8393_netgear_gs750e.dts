// SPDX-License-Identifier: GPL-2.0-or-later OR MIT

#include "rtl839x.dtsi"

#include <dt-bindings/input/input.h>
#include <dt-bindings/gpio/gpio.h>

/ {
	compatible = "netgear,gs750e", "realtek,rtl8393-soc";
	model = "Netgear GS750E";

	aliases {
		label-mac-device = &ethernet0;
	};

	memory@0 {
		device_type = "memory";
		reg = <0x0 0x8000000>;
	};

	keys {
		compatible = "gpio-keys";

		reset {
			label = "reset";
			gpios = <&gpio0 11 GPIO_ACTIVE_LOW>;
			linux,code = <KEY_RESTART>;
		};
	};

	gpio-restart {
		compatible = "gpio-restart";
		gpios = <&gpio0 10 GPIO_ACTIVE_LOW>;
	};

	virtual_flash {
		compatible = "mtd-concat";

		devices = <&fwconcat0>, <&fwconcat1>, <&fwconcat2>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "firmware";
				reg = <0x0 0x760000>;
				compatible = "openwrt,uimage", "denx,uimage";
				openwrt,ih-magic = <0x174e4741>;
			};
		};
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <10000000>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "u-boot";
				reg = <0x0 0x80000>;
				read-only;
			};

			partition@80000 {
				label = "u-boot-env";
				reg = <0x80000 0x10000>;
				read-only;
			};

			partition@90000 {
				label = "u-boot-env2";
				reg = <0x90000 0x10000>;
				read-only;
			};

			fwconcat1: partition@a0000 {
				label = "jffs2_cfg";
				reg = <0xa0000 0x80000>;
			};

			fwconcat2: partition@120000 {
				label = "jffs2_log";
				reg = <0x120000 0x80000>;
			};

			fwconcat0: partition@1a0000 {
				label = "runtime";
				reg = <0x1a0000 0x660000>;
			};
		};
	};
};

&mdio_bus0 {
	// Switch doesn't come back properly after a reset so don't.
	// reset-gpios = <&gpio0 23 GPIO_ACTIVE_LOW>;

	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C22(0, 0)
		PHY_C22(1, 1)
		PHY_C22(2, 2)
		PHY_C22(3, 3)
		PHY_C22(4, 4)
		PHY_C22(5, 5)
		PHY_C22(6, 6)
		PHY_C22(7, 7)
	};
	ethernet-phy-package@8 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <8>;

		PHY_C22(8, 8)
		PHY_C22(9, 9)
		PHY_C22(10, 10)
		PHY_C22(11, 11)
		PHY_C22(12, 12)
		PHY_C22(13, 13)
		PHY_C22(14, 14)
		PHY_C22(15, 15)
	};
	ethernet-phy-package@16 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <16>;

		PHY_C22(16, 16)
		PHY_C22(17, 17)
		PHY_C22(18, 18)
		PHY_C22(19, 19)
		PHY_C22(20, 20)
		PHY_C22(21, 21)
		PHY_C22(22, 22)
		PHY_C22(23, 23)
	};
};

&mdio_bus1 {
	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C22(24, 0)
		PHY_C22(25, 1)
		PHY_C22(26, 2)
		PHY_C22(27, 3)
		PHY_C22(28, 4)
		PHY_C22(29, 5)
		PHY_C22(30, 6)
		PHY_C22(31, 7)
	};
	ethernet-phy-package@8 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <8>;

		PHY_C22(32, 8)
		PHY_C22(33, 9)
		PHY_C22(34, 10)
		PHY_C22(35, 11)
		PHY_C22(36, 12)
		PHY_C22(37, 13)
		PHY_C22(38, 14)
		PHY_C22(39, 15)
	};
	ethernet-phy-package@16 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <16>;

		PHY_C22(40, 16)
		PHY_C22(41, 17)
		PHY_C22(42, 18)
		PHY_C22(43, 19)
		PHY_C22(44, 20)
		PHY_C22(45, 21)
		PHY_C22(46, 22)
		PHY_C22(47, 23)
	};
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		SWITCH_PORT_SDS(0, 1, 0, 0, qsgmii)
		SWITCH_PORT_SDS(1, 2, 0, 1, qsgmii)
		SWITCH_PORT_SDS(2, 3, 0, 2, qsgmii)
		SWITCH_PORT_SDS(3, 4, 0, 3, qsgmii)
		SWITCH_PORT_SDS(4, 5, 1, 0, qsgmii)
		SWITCH_PORT_SDS(5, 6, 1, 1, qsgmii)
		SWITCH_PORT_SDS(6, 7, 1, 2, qsgmii)
		SWITCH_PORT_SDS(7, 8, 1, 3, qsgmii)

		SWITCH_PORT_SDS(8, 9, 2, 0, qsgmii)
		SWITCH_PORT_SDS(9, 10, 2, 1, qsgmii)
		SWITCH_PORT_SDS(10, 11, 2, 2, qsgmii)
		SWITCH_PORT_SDS(11, 12, 2, 3, qsgmii)
		SWITCH_PORT_SDS(12, 13, 3, 0, qsgmii)
		SWITCH_PORT_SDS(13, 14, 3, 1, qsgmii)
		SWITCH_PORT_SDS(14, 15, 3, 2, qsgmii)
		SWITCH_PORT_SDS(15, 16, 3, 3, qsgmii)

		SWITCH_PORT_SDS(16, 17, 4, 0, qsgmii)
		SWITCH_PORT_SDS(17, 18, 4, 1, qsgmii)
		SWITCH_PORT_SDS(18, 19, 4, 2, qsgmii)
		SWITCH_PORT_SDS(19, 20, 4, 3, qsgmii)
		SWITCH_PORT_SDS(20, 21, 5, 0, qsgmii)
		SWITCH_PORT_SDS(21, 22, 5, 1, qsgmii)
		SWITCH_PORT_SDS(22, 23, 5, 2, qsgmii)
		SWITCH_PORT_SDS(23, 24, 5, 3, qsgmii)

		SWITCH_PORT_SDS(24, 25, 6, 0, qsgmii)
		SWITCH_PORT_SDS(25, 26, 6, 1, qsgmii)
		SWITCH_PORT_SDS(26, 27, 6, 2, qsgmii)
		SWITCH_PORT_SDS(27, 28, 6, 3, qsgmii)
		SWITCH_PORT_SDS(28, 29, 7, 0, qsgmii)
		SWITCH_PORT_SDS(29, 30, 7, 1, qsgmii)
		SWITCH_PORT_SDS(30, 31, 7, 2, qsgmii)
		SWITCH_PORT_SDS(31, 32, 7, 3, qsgmii)

		SWITCH_PORT_SDS(32, 33, 8, 0, qsgmii)
		SWITCH_PORT_SDS(33, 34, 8, 1, qsgmii)
		SWITCH_PORT_SDS(34, 35, 8, 2, qsgmii)
		SWITCH_PORT_SDS(35, 36, 8, 3, qsgmii)
		SWITCH_PORT_SDS(36, 37, 9, 0, qsgmii)
		SWITCH_PORT_SDS(37, 38, 9, 1, qsgmii)
		SWITCH_PORT_SDS(38, 39, 9, 2, qsgmii)
		SWITCH_PORT_SDS(39, 40, 9, 3, qsgmii)

		SWITCH_PORT_SDS(40, 41, 10, 0, qsgmii)
		SWITCH_PORT_SDS(41, 42, 10, 1, qsgmii)
		SWITCH_PORT_SDS(42, 43, 10, 2, qsgmii)
		SWITCH_PORT_SDS(43, 44, 10, 3, qsgmii)
		SWITCH_PORT_SDS(44, 45, 11, 0, qsgmii)
		SWITCH_PORT_SDS(45, 46, 11, 1, qsgmii)
		SWITCH_PORT_SDS(46, 47, 11, 2, qsgmii)
		SWITCH_PORT_SDS(47, 48, 11, 3, qsgmii)

		port@48 {
			reg = <48>;
			label = "lan49";
			pcs-handle = <&serdes12 0>;
			phy-mode = "1000base-x";
			managed = "in-band-status";
			/* i2c and gpio not yet identified */
		};
		port@49 {
			reg = <49>;
			label = "lan50";
			pcs-handle = <&serdes13 0>;
			phy-mode = "1000base-x";
			managed = "in-band-status";
			/* i2c and gpio not yet identified */
		};

		/* CPU-Port */
		port@52 {
			ethernet = <&ethernet0>;
			reg = <52>;
			phy-mode = "internal";
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};
