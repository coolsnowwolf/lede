// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl8380_zyxel_gs1900.dtsi"
#include "rtl8380_zyxel_gs1900_gpio.dtsi"

/ {
	compatible = "zyxel,gs1900-16-a1", "realtek,rtl838x-soc";
	model = "Zyxel GS1900-16 A1";
};

&mdio_bus0 {
	PHY_C22(16, 16)
	PHY_C22(17, 17)
	PHY_C22(18, 18)
	PHY_C22(19, 19)
	PHY_C22(20, 20)
	PHY_C22(21, 21)
	PHY_C22(22, 22)
	PHY_C22(23, 23)
};

&switch0 {
	ethernet-ports {
		SWITCH_PORT_SDS(16, 9, 2, 0, qsgmii)
		SWITCH_PORT_SDS(17, 10, 2, 1, qsgmii)
		SWITCH_PORT_SDS(18, 11, 2, 2, qsgmii)
		SWITCH_PORT_SDS(19, 12, 2, 3, qsgmii)
		SWITCH_PORT_SDS(20, 13, 3, 0, qsgmii)
		SWITCH_PORT_SDS(21, 14, 3, 1, qsgmii)
		SWITCH_PORT_SDS(22, 15, 3, 2, qsgmii)
		SWITCH_PORT_SDS(23, 16, 3, 3, qsgmii)
	};
};

&gpio1 {
	/delete-node/ poe_enable;
};
