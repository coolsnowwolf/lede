// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl9313_zyxel_xs1930-aqr813.dtsi"

#include <dt-bindings/input/input.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/leds/common.h>
#include <dt-bindings/mux/mux.h>
#include <dt-bindings/phy/phy.h>

/ {
	compatible = "zyxel,xs1930-12hp", "realtek,rtl9313-soc";
	model = "Zyxel XS1930-12HP";

	leds {
		led_poe_max: led-7 {
			color = <LED_COLOR_ID_RED>;
			function = "poe-usage";
			gpios = <&gpio0 3 GPIO_ACTIVE_LOW>;
		};
	};
};

&led_set {
	/* Phantom port chain padding (2 LEDs) */
	led_set1 = <RTL93XX_LED_SET_NONE
		    RTL93XX_LED_SET_NONE>;

	/* The LED PCB has two daisy-chained RTL8231 in scan mode.
	 * Net LEDs for P3-P12 are on the first RTL8231, P1/P2
	 * net LEDs are on the second. The 12 real ports provide
	 * 36 LED bits but the chain requires 65 bits to correctly
	 * span both chips. Phantom ports 1-7, 9-10 (set0, 3 LEDs
	 * each) and port 11 (set1, 2 LEDs) pad the chain with
	 * the remaining 29 bits.
	 */
	realtek,led-set0-force-port-mask = <0x00000000 0x000006FE>;
	realtek,led-set1-force-port-mask = <0x00000000 0x00000800>;
};

&led_sys_green { gpios = <&gpio0 23 GPIO_ACTIVE_LOW>; };
&led_sys_red { gpios = <&gpio0 0 GPIO_ACTIVE_LOW>; };

&i2c_mst1 {
	i2c3: i2c@3 {
		reg = <3>;
		#address-cells = <1>;
		#size-cells = <0>;

		pse: ethernet-pse@20 {
			compatible = "zyxel,xs1930-12hp-pse", "realtek,pse-mcu-gen2-smbus";
			reg = <0x20>;

			disable-ports-gpios = <&gpio0 30 GPIO_ACTIVE_LOW>;
			reset-gpios = <&gpio0 10 GPIO_ACTIVE_LOW>;

			pse-pis {
				#address-cells = <1>;
				#size-cells = <0>;

				PSE_PI(0)
				PSE_PI(1)
				PSE_PI(2)
				PSE_PI(3)
				PSE_PI(4)
				PSE_PI(5)
				PSE_PI(6)
				PSE_PI(7)
			};
		};
	};
};

&mdio_ctrl {
	pinctrl-names = "default";
	pinctrl-0 = <&pinmux_enable_mdc_mdio_0>,
		    <&pinmux_enable_mdc_mdio_1>,
		    <&pinmux_enable_mdc_mdio_2>;
};

&mdio_bus1 {
	PHY_C45(52, 0)	/* AQR113C */
};

&mdio_bus2 {
	PHY_C45(53, 8)	/* AQR113C */
};

&phy0 { pses = <&pse_pi0>; };
&phy8 { pses = <&pse_pi1>; };
&phy16 { pses = <&pse_pi2>; };
&phy24 { pses = <&pse_pi3>; };
&phy32 { pses = <&pse_pi4>; };
&phy40 { pses = <&pse_pi5>; };
&phy48 { pses = <&pse_pi6>; };
&phy50 { pses = <&pse_pi7>; };

&switch0 {
	ethernet-ports {
		/* Copper ports behind AQR113C */
		SWITCH_PORT_LED(52, 9, 10, 0, 0, usxgmii)
		SWITCH_PORT_LED(53, 10, 11, 0, 0, usxgmii)

		SWITCH_PORT_SFP(54, 11, 12, 0, 1)
		SWITCH_PORT_SFP(55, 12, 13, 0, 2)
	};
};

&port52 { managed = "in-band-status"; };
&port53 { managed = "in-band-status"; };

&serdes10 { tx-polarity = <PHY_POL_INVERT>; };
&serdes11 { tx-polarity = <PHY_POL_INVERT>; };

