// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl9302_zyxel_xgs1010-12-common.dtsi"

/ {
	compatible = "zyxel,xgs1010-12-a1", "realtek,rtl930x-soc";
	model = "Zyxel XGS1010-12 A1";
};

&mdio_bus1 {
	PHY_C45_PAIR_ORDER(24, 8, 1)
};

&mdio_bus2 {
	PHY_C45_PAIR_ORDER(25, 9, 1)
};
